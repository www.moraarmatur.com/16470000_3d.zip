Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2x3 Coordination View
File name: D:\Users\Jonas\Documents\Cadfocus\Ostnor\Projekt\20140212_CAD-objekt_Göran_prio2\ARBETSMAPP\16470000\AutoCAD Architecture\16470000.ifc
Time: 2014-03-04T14:40:47
Author: - -
Organization: Ostnor AB
Written by: Eurostep IFC Toolbox - 1.0
Made in: AutoCAD Architecture 2009 Build 5.7.68.0

# IfcProject, 16470000
LongName: 16470000
PSET_ACA_DISPLAY_SET - ACA_DISPLAY_CONFIG_ON_EXPORT: 02 - Normal detaljering; ACA_DISPLAY_SET_ON_EXPORT: 3D Normal

# IfcBuilding, 16470000
ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm

# IfcBuildingElementProxy: 16470000, BUILDINGELEMENTPROXY(1)
In: 16470000
Description: FM Mattsson 16470000, 9000E Tronic washbasin mixer, with temperature lever and self-closing hand shower, chrome
